# Keil uVision project LED闪烁.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: LED闪烁 +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group User
    ./User/: system_stm32f10x.c clock.c led.c main.c daley.c
