# Keil uVision project LED闪烁.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED闪烁 +hex
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: .\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: STM32F10x.s
  group User
    ./User/: system_stm32f10x.c clock.c led.c main.c daley.c
software components: CMSIS:CORE 4.3.0
